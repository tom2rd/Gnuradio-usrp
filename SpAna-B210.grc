options:
  parameters:
    generate_options: qt_gui
    id: SpAna_B210
    output_language: python
    title: B210Spana
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: 192*10**3
    step: 1*10**3
    stop: 56*10**6
    value: 50*10**6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: 70*10**6
    step: 100*10**6
    stop: 6*10**9
    value: 100*10**6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"Spectrum Analyzer"'
    showports: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 4*10**6
    center_freq0: tuning
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, async_msgs, qtgui_sink_x_0, freq]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
